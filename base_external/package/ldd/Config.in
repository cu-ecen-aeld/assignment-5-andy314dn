## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd-package"
    help
      This package builds and installs misc-modules and scull components.
```
